# Habilitar KMS/DRM
PACKAGECONFIG:append = " kmsdrm"


